# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR LAB5
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab5.def
  group Source
    ./: startup.s Lab5.c eFile.c ff.c loader.c DataCollectors.c DataCollectors.h Blynk.h
    ../inc/: LaunchPad.c PLL.c ADCT0ATrigger.c ADCSWTrigger.c LPF.c IRDistance.c WTimer0A.c Timer0A.c Timer1A.c Timer2A.c Timer3A.c Timer4A.c Timer5A.c
    ../RTOS_Labs_common/: OS.c ST7735.c Interpreter.c UART0int.c eDisk.c osasm.s ADC.c heap.c systick.s
    ../Lab4_Blynk_4C123/: Blynk.c esp8266.c esp8266.h
software components: CMSIS:CORE 5.0.2
